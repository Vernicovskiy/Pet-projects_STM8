<?xml version="1.0" encoding="iso-8859-1"?>

<project>
  <fileVersion>2</fileVersion>
  <configuration>
    <name>Debug</name>
    <toolchain>
      <name>STM8</name>
    </toolchain>
    <debug>1</debug>
  </configuration>
  <configuration>
    <name>Release</name>
    <toolchain>
      <name>STM8</name>
    </toolchain>
    <debug>0</debug>
  </configuration>
  <group>
    <name>inc</name>
    <file>
      <name>$PROJ_DIR$\..\..\..\socket\GSM_socket\inc\stm8s.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\socket\GSM_socket\inc\stm8s_adc1.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\socket\GSM_socket\inc\stm8s_adc2.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\socket\GSM_socket\inc\stm8s_awu.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\socket\GSM_socket\inc\stm8s_beep.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\socket\GSM_socket\inc\stm8s_can.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\socket\GSM_socket\inc\stm8s_clk.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\socket\GSM_socket\inc\stm8s_conf.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\socket\GSM_socket\inc\stm8s_exti.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\socket\GSM_socket\inc\stm8s_flash.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\socket\GSM_socket\inc\stm8s_gpio.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\socket\GSM_socket\inc\stm8s_i2c.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\socket\GSM_socket\inc\stm8s_itc.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\socket\GSM_socket\inc\stm8s_iwdg.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\socket\GSM_socket\inc\stm8s_rst.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\socket\GSM_socket\inc\stm8s_spi.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\socket\GSM_socket\inc\stm8s_tim1.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\socket\GSM_socket\inc\stm8s_tim2.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\socket\GSM_socket\inc\stm8s_tim3.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\socket\GSM_socket\inc\stm8s_tim4.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\socket\GSM_socket\inc\stm8s_tim5.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\socket\GSM_socket\inc\stm8s_tim6.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\socket\GSM_socket\inc\stm8s_uart1.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\socket\GSM_socket\inc\stm8s_uart2.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\socket\GSM_socket\inc\stm8s_uart3.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\socket\GSM_socket\inc\stm8s_uart4.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\socket\GSM_socket\inc\stm8s_wwdg.h</name>
    </file>
  </group>
  <file>
    <name>$PROJ_DIR$\main.c</name>
  </file>
</project>


